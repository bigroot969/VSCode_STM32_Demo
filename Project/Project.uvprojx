# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10x_MD
  c include: ..\CMSIS;..\Libraries\inc;..\Libraries\src;..\Start;..\User;..\System;..\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Start
    ../Start/: startup_stm32f10x_md.s
  group System
    ../System/: ADCx.c ADCx.h Delay.c Delay.h MyRTC.c MyRTC.h Sys.c Sys.h Timer.c Timer.h
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c
  group Hardware
    ../Hardware/: GUI.c GUI.h Menu.c Menu.h W25Q64.c W25Q64.h W25Q64_Ins.h Buzzer.c Buzzer.h BuzzerData.c BuzzerData.h DataStorage.c DataStorage.h Font.h LCD.c LCD.h LED.c LED.h LightSensor.c LightSensor.h PWM.c PWM.h TempSensor.c TempSensor.h OLED.c OLED.h OLED_Data.c OLED_Data.h SPI2.c SPI2.h MySPI.c MySPI.h Key.c Key.h
